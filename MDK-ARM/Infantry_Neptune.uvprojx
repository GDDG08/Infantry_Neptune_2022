# Keil uVision project Infantry_Neptune.uvprojx, settings and files
target Infantry_Neptune (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Infantry_Neptune +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F405xx,ARM_MATH_CM4,__TARGET_FPU_VFP,__CC_ARM
  c include: ../Core/Inc;                    ../Drivers/STM32F4xx_HAL_Driver/Inc;                    ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                    ../Middlewares/Third_Party/FreeRTOS/Source/include;                    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;                    ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                    ../Drivers/CMSIS/Include;                    ..\Drivers\CMSIS\DSP\Include;                    ..\Core\Inc;                    ..\Core\Inc\Algorithm;                    ..\Core\Inc\Library;                    ..\Core\Inc\Peripheral;                    ..\Core\Inc\Utility;                    ..\Core\Inc\Chassis_Control;                    ..\Core\Inc\Gimbal_Control;                    ..\Core\Inc\SuperCap_Control;                    ..\Core\Inc\Common_Contrrol;                    ..\Core\Inc\Const
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Application/User/Core
    ../Core/Inc/: configure.h
    ../Core/Src/: main.c gpio.c freertos.c adc.c can.c dac.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Utility
    ../Core/Src/Utility/: adc_util.c can_util.c dac_util.c gpio_util.c pwm_util.c uart_util.c i2c_util.c spi_util.c flash_util.c
  group Peripheral
    ../Core/Src/Peripheral/: led_periph.c miniPC_periph.c motor_periph.c referee_periph.c remote_periph.c sensor_periph.c servo_periph.c oled_periph.c key_periph.c magnetic_periph.c bma2x2_periph.c bmg160_periph.c bmi055_periph.c bmi088_periph.c hi22x_periph.c
  group Gimbal_Control
    ../Core/Src/Gimbal_Control/: gim_gimbal_ctrl.c gim_miniPC_ctrl.c gim_remote_ctrl.c gim_shoot_ctrl.c gim_client_ctrl.c gim_login_ctrl.c gim_ins_ctrl.c
  group Chassis_Control
    ../Core/Src/Chassis_Control/: cha_chassis_ctrl.c cha_gimbal_ctrl.c cha_power_ctrl.c cha_referee_ctrl.c
  group SuperCap_Control
    ../Core/Src/SuperCap_Control/: supercap_ctrl.c
  group Common_Control
    ../Core/Src/Common_Contrrol/: buscomm_cmd.c buscomm_ctrl.c watchdog_ctrl.c init_ctrl.c
  group Algorithm
    ../Core/Src/Algorithm/: ahrs_alg.c filter_alg.c kalman_alg.c math_alg.c adrc_alg.c pid_alg.c crc_alg.c
    ../Drivers/CMSIS/DSP/Include/: arm_cortexM4lf_math.lib
  group Library
    ../Core/Src/Library/: buff_lib.c log_lib.c list_lib.c str_lib.c font_lib.c gif_lib.c
  group Const
    ../Core/Src/Const/: infantry3_const.c infantry4_const.c infantry5_const.c infantry6_const.c infantry7_const.c infantry8_const.c const.c
software components: CMSIS:CORE 4.3.0
